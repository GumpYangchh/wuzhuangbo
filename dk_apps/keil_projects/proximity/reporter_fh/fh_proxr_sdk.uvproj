# Keil uVision project fh_proxr_sdk.uvproj, settings and files
target Full_emb_cortex_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: full_emb_sysram +hex
  c flags: Optim=4 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h --bss_threshold=0
  c include: .\..\..\..\src\dialog\include;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\..\..\src\plf\refip\src\arch;.\..\..\..\src\plf\refip\src\arch\compiler\rvds;.\..\..\..\src\plf\refip\src\arch\boot\rvds;.\..\..\..\src\plf\refip\src\arch\ll\rvds;.\..\..\..\src\plf\refip\src\driver\reg;.\..\..\..\src\modules\common\api;.\..\..\..\src\modules\dbg\api;.\..\..\..\src\modules\display\api;.\..\..\..\src\modules\gtl\api;.\..\..\..\src\modules\ke\api;.\..\..\..\src\modules\ke\src;.\..\..\..\src\modules\nvds\api;.\..\..\..\src\modules\rf\api;.\..\..\..\src\modules\rwip\api;.\..\..\..\src\ip\ble\ll\src\rwble;.\..\..\..\src\ip\ble\ll\src\controller\em;.\..\..\..\src\ip\ble\ll\src\controller\llc;.\..\..\..\src\ip\ble\ll\src\controller\lld;.\..\..\..\src\ip\ble\ll\src\controller\llm;.\..\..\..\src\plf\refip\src\driver\led;.\..\..\..\src\plf\refip\src\driver\timer;.\..\..\..\src\plf\refip\src\driver\syscntl;.\..\..\..\src\plf\refip\src\driver\emi;.\..\..\..\src\plf\refip\src\driver\uart;.\..\..\..\src\plf\refip\src\driver\flash;.\..\..\..\src\plf\refip\src\driver\gpio;.\..\..\..\src\ip\ble\hl\src\host\att;.\..\..\..\src\ip\ble\hl\src\host\att\attc;.\..\..\..\src\ip\ble\hl\src\host\att\attm;.\..\..\..\src\ip\ble\hl\src\host\gap;.\..\..\..\src\ip\ble\hl\src\host\gap\gapc;.\..\..\..\src\ip\ble\hl\src\host\gap\gapm;.\..\..\..\src\ip\ble\hl\src\host\att\atts;.\..\..\..\src\ip\ble\hl\src\host\gatt;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattc;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattm;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cc;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cm;.\..\..\..\src\ip\ble\hl\src\host\smp\smpc;.\..\..\..\src\ip\ble\hl\src\host\smp\smpm;.\..\..\..\src\ip\ble\hl\src\profiles;.\..\..\..\src\ip\ble\hl\src\profiles\accel;.\..\..\..\src\ip\ble\hl\src\profiles\bas\basc;.\..\..\..\src\ip\ble\hl\src\profiles\bas\bass;.\..\..\..\src\ip\ble\hl\src\profiles\blp;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blpc;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blps;.\..\..\..\src\ip\ble\hl\src\profiles\dis\disc;.\..\..\..\src\ip\ble\hl\src\profiles\dis\diss;.\..\..\..\src\ip\ble\hl\src\profiles\find\findl;.\..\..\..\src\ip\ble\hl\src\profiles\find\findt;.\..\..\..\src\ip\ble\hl\src\profiles\hogp;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpbh;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpd;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogprh;.\..\..\..\src\ip\ble\hl\src\profiles\hrp;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrpc;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrps;.\..\..\..\src\ip\ble\hl\src\profiles\htp;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpc;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpt;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxm;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxr;.\..\..\..\src\ip\ble\hl\src\profiles\scpp;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scppc;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scpps;.\..\..\..\src\plf\refip\src\driver\intc;.\..\..\..\src\ip\ble\hl\src\rwble_hl;.\..\..\..\src\ip\ble\ll\src\hcic;.\..\..\..\src\ip\ble\hl\src\host\smp;.\..\..\..\src\modules\app\api;.\..\..\..\src\modules\gtl\src;.\..\..\..\src\ip\ble\hl\src\profiles\anp;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anpc;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anps;.\..\..\..\src\ip\ble\hl\src\profiles\cscp;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscpc;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscps;.\..\..\..\src\ip\ble\hl\src\profiles\glp;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glpc;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glps;.\..\..\..\src\ip\ble\hl\src\profiles\pasp;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\paspc;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\pasps;.\..\..\..\src\ip\ble\hl\src\profiles\rscp;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscpc;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscps;.\..\..\..\src\ip\ble\hl\src\profiles\tip;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tipc;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tips;.\..\..\..\src\ip\ble\hl\src\profiles\cpp;.\..\..\..\src\ip\ble\hl\src\profiles\cpp\cppc;.\..\..\..\src\ip\ble\hl\src\profiles\cpp\cpps;.\..\..\..\src\ip\ble\hl\src\profiles\lan;.\..\..\..\src\ip\ble\hl\src\profiles\lan\lanc;.\..\..\..\src\ip\ble\hl\src\profiles\lan\lans;.\..\..\..\src\modules\app\src\;.\..\..\..\src\modules\app\src\app_profiles\prox_reporter;.\..\..\..\src\modules\app\src\app_profiles\bass;.\..\..\..\src\modules\app\src\app_profiles\diss;.\..\..\..\src\modules\app\src\app_profiles\findme;.\..\..\..\src\modules\app\src\app_project\prox_reporter_fh;.\..\..\..\src\plf\refip\src\driver\adc;.\..\..\..\src\modules\app\src\app_project\prox_reporter_fh\system;.\..\..\..\src\plf\refip\src\driver\wkupct_quadec;.\..\..\..\src\plf\refip\src\driver\battery;.\..\..\..\src\modules\app\src\app_utils\app_console;..\..\..\src\modules\app\src\app_profiles\spotar;..\..\..\src\modules\app\src\app_project\spotar_fh;..\..\..\src\plf\refip\src\driver\spi;..\..\..\src\ip\ble\hl\src\profiles\spota\spotar;..\..\..\src\plf\refip\src\driver\spi_flash;..\..\..\src\plf\refip\src\driver\i2c_eeprom;.\..\..\..\src\ip\ble\hl\src\profiles\sample128;.\..\..\..\src\modules\app\src\app_profiles\sample128
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: ..\..\..\scatterfiles\scatterfile_common.sct
  link misc: ..\..\..\misc\rom_symdef.txt  --symdefs=full_emb_sysram_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group boot
    ./../../../src/plf/refip/src/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ../../../src/plf/refip/src/arch/main/ble/: hardfault_handler.c
  group arch
    ./../../../src/plf/refip/src/arch/main/ble/: arch_main.c jump_table.c
    ../../../src/plf/refip/src/arch/main/ble/: arch_sleep.c nmi_handler.c arch_system.c
    ../../../src/modules/app/src/app_project/prox_reporter_fh/system/: periph_setup.c
  group driver
    ./../../../src/modules/rf/src/: rf_580.c
    ../../../src/plf/refip/src/driver/gpio/: gpio.c
    ../../../src/plf/refip/src/driver/wkupct_quadec/: wkupct_quadec.c
    ../../../src/plf/refip/src/driver/battery/: battery.c
    ../../../src/plf/refip/src/driver/adc/: adc.c
    ../../../src/plf/refip/src/driver/spi_flash/: spi_flash.c
    ../../../src/plf/refip/src/driver/spi/: spi.c
    ../../../src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
  group ke
    ../../../patch_code/obj/: ke_task.obj ch_map.obj
  group host
    ./../../../src/ip/ble/hl/src/host/gap/gapm/: gapm.c
    ../../../patch_code/obj/: atts_task.obj smpc.obj smpc_task.obj gapm_util.obj
  group nvds
    ./../../../src/modules/nvds/src/: nvds.c
  group rwble
    ./../../../src/modules/rwip/src/: rwip.c
    ./../../../src/ip/ble/ll/src/rwble/: rwble.c
  group profiles
    ./../../../src/ip/ble/hl/src/profiles/accel/: accel.c accel_task.c
    ./../../../src/ip/ble/hl/src/profiles/bas/basc/: basc.c basc_task.c
    ./../../../src/ip/ble/hl/src/profiles/bas/bass/: bass.c bass_task.c
    ./../../../src/ip/ble/hl/src/profiles/blp/blpc/: blpc.c blpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/blp/blps/: blps.c blps_task.c
    ./../../../src/ip/ble/hl/src/profiles/dis/disc/: disc.c disc_task.c
    ./../../../src/ip/ble/hl/src/profiles/dis/diss/: diss.c diss_task.c
    ./../../../src/ip/ble/hl/src/profiles/find/findt/: findt.c findt_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogpbh/: hogpbh.c hogpbh_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogprh/: hogprh.c hogprh_task.c
    ./../../../src/ip/ble/hl/src/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/hrp/hrps/: hrps.c hrps_task.c
    ./../../../src/ip/ble/hl/src/profiles/htp/htpc/: htpc.c htpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/htp/htpt/: htpt.c htpt_task.c
    ./../../../src/ip/ble/hl/src/profiles/prox/proxm/: proxm.c proxm_task.c
    ./../../../src/ip/ble/hl/src/profiles/prox/proxr/: proxr.c proxr_task.c
    ./../../../src/ip/ble/hl/src/profiles/scpp/scppc/: scppc.c scppc_task.c
    ./../../../src/ip/ble/hl/src/profiles/scpp/scpps/: scpps.c scpps_task.c
    ./../../../src/ip/ble/hl/src/profiles/: prf_utils.c
    ./../../../src/ip/ble/hl/src/profiles/anp/anpc/: anpc.c anpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/anp/anps/: anps.c anps_task.c
    ./../../../src/ip/ble/hl/src/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/cscp/cscps/: cscps.c cscps_task.c
    ./../../../src/ip/ble/hl/src/profiles/glp/glpc/: glpc.c glpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/glp/glps/: glps.c glps_task.c
    ./../../../src/ip/ble/hl/src/profiles/pasp/paspc/: paspc.c paspc_task.c
    ./../../../src/ip/ble/hl/src/profiles/pasp/pasps/: pasps.c pasps_task.c
    ./../../../src/ip/ble/hl/src/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/rscp/rscps/: rscps.c rscps_task.c
    ./../../../src/ip/ble/hl/src/profiles/tip/tipc/: tipc.c tipc_task.c
    ./../../../src/ip/ble/hl/src/profiles/tip/tips/: tips.c tips_task.c
    ../../../src/ip/ble/hl/src/profiles/find/findl/: findl.c findl_task.c
    ../../../src/ip/ble/hl/src/profiles/cpp/cppc/: cppc.c cppc_task.c
    ../../../src/ip/ble/hl/src/profiles/cpp/cpps/: cpps.c cpps_task.c
    ../../../src/ip/ble/hl/src/profiles/lan/lanc/: lanc.c lanc_task.c
    ../../../src/ip/ble/hl/src/profiles/lan/lans/: lans.c lans_task.c
    ../../../src/ip/ble/hl/src/profiles/spota/spotar/: spotar.c spotar_task.c
    ../../../src/ip/ble/hl/src/profiles/sample128/: sample128.c sample128_task.c
  group app
    ./../../../src/modules/app/src/: app.c app_sec.c app_sec_task.c app_task.c
    ../../../src/modules/app/src/app_profiles/bass/: app_batt.c app_batt_task.c
    ../../../src/modules/app/src/app_profiles/findme/: app_findme.c app_findme_task.c
    ../../../src/modules/app/src/app_profiles/prox_reporter/: app_proxr.c app_proxr_task.c
    ../../../src/modules/app/src/app_profiles/diss/: app_dis.c app_dis_task.c
    ../../../src/modules/app/src/app_project/prox_reporter_fh/: app_proxr_proj.c
    ../../../src/modules/app/src/app_profiles/spotar/: app_spotar.c app_spotar_task.c
    ../../../src/modules/app/src/app_profiles/sample128/: app_sample128.c app_sample128_task.c
